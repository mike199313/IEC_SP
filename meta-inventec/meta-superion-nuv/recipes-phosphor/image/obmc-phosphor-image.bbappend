OBMC_IMAGE_EXTRA_INSTALL:append = " superion-nuv-init"
OBMC_IMAGE_EXTRA_INSTALL:append = " smbios-mdr smbios-mdr-reload"
